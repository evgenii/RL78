# IAR project data_flash_T04_R5F104PJ.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: dataflash_lib
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: linker\data_flash_sample_linker_file_R5F104xJ.xcl
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: R5F104LE RL78 - R5F104LE
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: applilet3_src\md_lnkr5f104le.xcl
  group applilet_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_it.c r_cg_it_user.c r_cg_port.c r_cg_port_user.c r_main.c r_systeminit.c
  group data_flash_lib
    dataflash_lib/: pfdl.r87
