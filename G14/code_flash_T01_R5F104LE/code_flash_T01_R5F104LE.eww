<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\code_flash_T01_R5F104LE.ewp</path>
  </project>
  <batchBuild />
</workspace>


