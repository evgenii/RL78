<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_test_dma_single_channel.ewp</path>
  </project>
  <batchBuild />
</workspace>


