# IAR project RPBRL78L12_lcd_demo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10RLC RL78 - R5F10RLC
  XLINK.XclFile: applilet3_src\md_lnkr5f10rlc.xcl
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_serial.c r_cg_serial_user.c r_cg_adc.c r_cg_adc_user.c r_cg_rtc.c r_cg_rtc_user.c r_cg_it.c r_cg_it_user.c r_cg_lcd_RPB.c r_cg_lcd_user_RPB.c
