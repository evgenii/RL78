<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RPBRL78L12_lcd_demo.ewp</path>
  </project>
  <batchBuild />
</workspace>


