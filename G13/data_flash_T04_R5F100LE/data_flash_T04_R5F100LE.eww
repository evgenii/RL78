<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\data_flash_T04_R5F100LE.ewp</path>
  </project>
  <batchBuild />
</workspace>


