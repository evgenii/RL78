<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\application_T01_R5F100LE\application_T01_R5F100LE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader_T01_R5F100LE\bootloader_T01_R5F100LE.ewp</path>
  </project>
  <batchBuild/>
</workspace>


