# IAR project bootloader_T01_R5F100LE.ewp, settings and files
configuration R5F100LE_internal_mode (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: BOOTLOADER
  ICCRL78.CCIncludePath2: applilet3_src; fslib; user_src; ..\common
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: linker\bootloader_linker_file_SCI_R5F100xE.xcl
  group (top)
    applilet3_src/: BL_cstartup.s87
  group applilet_src
    applilet3_src/: BL_r_cg_cgc.c BL_r_cg_cgc.h BL_r_cg_cgc_user.c BL_r_cg_intc.c BL_r_cg_intc.h BL_r_cg_intc_user.c BL_r_cg_it.c BL_r_cg_it.h BL_r_cg_it_user.c BL_r_cg_macrodriver.h BL_r_cg_port.c BL_r_cg_port.h BL_r_cg_port_user.c BL_r_cg_userdefine.h BL_r_main_internal_mode.c BL_r_systeminit.c
  group common
    ../common/: interrupts.c
  group fslib
    fslib/: fsl.r87
  group user_src
    user_src/: fsl_user.c fsl_user_ram_functions.c
