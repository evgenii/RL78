# IAR project code_flash_T01_R5F107DE.ewp, settings and files
configuration R5F107DE_internal_mode (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F107DE RL78 - R5F107DE
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: fslib; user_src; applilet3_src
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: linker\fsl_sample_linker_file_SCI_R5F107xE.xcl
configuration R5F107DE_user_mode (RL78, debug)
  as the first configuration, except:
  XLINK.XclFile: linker\fsl_sample_linker_file_SCU_R5F107xE.xcl
  group applilet_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_it.c r_cg_it_user.c r_cg_port.c r_cg_port_user.c r_main_internal_mode.c r_main_user_mode.c r_systeminit.c
  group fslib
    fslib/: fsl.r87
  group user_src
    user_src/: fsl_user.c fsl_user_ram_functions.c
