# IAR project dtc_pwm_tone.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104LE RL78 - R5F104LE
  XLINK.XclFile: applilet3_src\md_lnkr5f104le.xcl
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_timer.c r_cg_timer_user.c r_cg_it.c r_cg_it_user.c r_cg_dtc.c r_cg_dtc_user.c
