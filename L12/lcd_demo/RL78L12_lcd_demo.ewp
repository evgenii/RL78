# IAR project RL78L12_lcd_demo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 512
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F10RLC RL78 - R5F10RLC
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ..\..\BSP; applilet3_src; user_src
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: applilet3_src\md_lnkr5f10rlc.xcl
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  ICCRL78.CCDefines: NDEBUG
  group applilet_src
    applilet3_src/: r_cg_adc.c r_cg_adc_user.c r_cg_cgc.c r_cg_cgc_user.c r_cg_it.c r_cg_it_user.c r_cg_lcd.c r_cg_lcd_user.c r_cg_rtc.c r_cg_rtc_user.c r_cg_serial.c r_cg_serial_user.c r_main.c r_systeminit.c
  group BSP
    ../../BSP/LCD/: LCD_T6022A.c
  group linker
    applilet3_src/: md_lnkr5f10rlc.xcl
